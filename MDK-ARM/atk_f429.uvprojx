# Keil uVision project atk_f429.uvprojx, settings and files
target TFTLCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f429 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ..;../Core/Inc;../BSP/Inc;../BSP/LCD;../BSP/LED;../BSP/KEY;../BSP/24CXX;../BSP/ADC;../BSP/REMOTE;../BSP/AP3216C;../BSP/ST480MC;../BSP/SH3001;../BSP/ES8388;../BSP/SAI;../BSP/SDIO;../BSP/SDRAM;../BSP/NORFLASH;../BSP/NAND;../BSP/SPI;../BSP/IIC;../BSP/PCF8574;../BSP/ETHERNET;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/STM32F4xx_HAL_Driver/Inc;../Middlewares/SYSTEM/delay;../Middlewares/SYSTEM/sys;../Middlewares/SYSTEM/usart;../App/Inc
  group Core/Src
    ../Core/Src/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Core/Startup
    ../Core/Startup/: startup_stm32f429xx.s
  group Drivers/HAL
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c
  group Middlewares/SYSTEM
    ../Middlewares/SYSTEM/delay/: delay.c
    ../Middlewares/SYSTEM/sys/: sys.c
    ../Middlewares/SYSTEM/usart/: usart.c
  group BSP
    ../BSP/24CXX/: 24cxx.c
    ../BSP/ADC/: adc.c
    ../BSP/AP3216C/: ap3216c.c
    ../BSP/ES8388/: es8388.c
    ../BSP/IIC/: myiic.c
    ../BSP/KEY/: key.c
    ../BSP/LCD/: lcd.c
    ../BSP/LED/: led.c
    ../BSP/NORFLASH/: norflash.c
    ../BSP/PCF8574/: pcf8574.c
    ../BSP/REMOTE/: remote.c
    ../BSP/SAI/: sai.c
    ../BSP/SDIO/: sdio_sdcard.c
    ../BSP/SDRAM/: sdram.c
    ../BSP/SH3001/: sh3001.c imu.c
    ../BSP/SPI/: spi.c
    ../BSP/ST480MC/: st480mc.c
    ../BSP/Src/: bsp_led.c bsp_lcd.c bsp_key.c
  group App
    ../App/Src/: app_test.c
